<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dropped_samp_detect</value></param>
<param><key>author</key><value>J. A. Gilbert</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Detects and prints info on dropped samples</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Dropped Sample Detector</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>b200_mclk</value></param>
<param><key>value</key><value>32*1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>858</value></param>
<param><key>label</key><value>Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>is_x300</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>is_x300</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mclk</value></param>
<param><key>value</key><value>x300_mclk*is_x300 + b200_mclk*(not is_x300)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>12.5*is_x300 + 8*(not is_x300)</value></param>
<param><key>label</key><value>Throttle (MS/s)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.01</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>x300_mclk</value></param>
<param><key>value</key><value>200*1e6</value></param>
</block>
<block>
<key>misc_debug_utils_dropped_samp_detector</key>
<param><key>id</key><value>misc_debug_utils_dropped_samp_detector_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq * 1e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"*is_x300</value></param>
<param><key>dev_args</key><value>"master_clock_rate=" + str(int(mclk))</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rate*1e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>misc_debug_utils_dropped_samp_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
