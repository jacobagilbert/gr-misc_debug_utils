<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tags_strobe_issue</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tag_period</value></param>
<param><key>value</key><value>128</value></param>
<param><key>label</key><value>Tag Period</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>4</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8192</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("BURST")</value></param>
<param><key>nsamps</key><value>tag_period</value></param>
<param><key>type</key><value>short</value></param>
<param><key>value</key><value>pmt.intern("BURST")</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>maxoutbuf</key><value>16</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
